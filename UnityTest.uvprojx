# Keil uVision project UnityTest.uvprojx, settings and files
target Unity (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UnityTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Unity\src;.\Unity\extras\fixture\src;.\TestCase\mocks;.\TestCase\LedDriver;.\include\LedDriver;.\include\util;.\TestCase\HomeAutomation;.\TestCase\include\HomeAutomation
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group Unity
    ./Unity/extras/fixture/src/: unity_fixture.c
    ./Unity/src/: unity.c
  group Mock
    ./TestCase/mocks/: RuntimeErrorStub.c
  group printf
    ./TestCase/stdio/: SprintfTest.c SprintfTestRunner.c
  group LedDriver
    ./TestCase/LedDriver/: LedDriverTest.c LedDriverTestRunner.c
    ./src/LedDriver/: LedDriver.c
  group UnityFixture
    ./Unity/extras/fixture/test/: unity_fixture_Test.c unity_fixture_TestRunner.c unity_output_Spy.c
  group HomeAutomation
    ./src/HomeAutomation/: LightScheduler.c
    ./TestCase/HomeAutomation/: FakeTimeService.c FakeTimeServiceTest.c FakeTimeServiceTest_runner.c LightControllerSpy.c LightControllerSpyTest.c LightControllerSpyTest_runner.c LightSchedulerTest.c LightSchedulerTest_runner.c
software components: CMSIS:CORE 4.3.0, Compiler:I/O:STDOUT 1.0.0, Device:Startup 2.4.2
